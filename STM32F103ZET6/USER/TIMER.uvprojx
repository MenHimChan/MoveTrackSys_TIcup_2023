# Keil uVision project TIMER.uvprojx, settings and files
target TIMER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\StepMotor;..\HARDWARE\led;..\HARDWARE\KEY;..\HARDWARE\McWheel;..\HARDWARE\function;..\HARDWARE\USART-HMI;..\HARDWARE\UART4_OPENMV
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/StepMotor/: StepMotor.c StepMotor.h
    ../HARDWARE/KEY/: KEY.c KEY.h
    ../HARDWARE/led/: led.c led.h
    ../HARDWARE/McWheel/: McWheel.c
    ../HARDWARE/function/: function.c
    ../HARDWARE/USART-HMI/: usart-hmi.c
    ../HARDWARE/UART4_OPENMV/: UART4_OPENMV.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c
  group README
    ../: README.TXT
